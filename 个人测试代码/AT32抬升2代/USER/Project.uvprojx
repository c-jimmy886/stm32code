# Keil uVision project Project.uvprojx, settings and files
target TEST (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: -AT32F403AVGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.2.0
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403AVGT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1
  c include: ..\CORE;..\CORE\inc;..\CMSIS\core_support;..\AT32f403a_FWLIB\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\FreeRTOS\portable\memmang;..\BSP;..\USER;..\MY;..\SYSTEM\sys;..\SYSTEM\usart;..\SYSTEM\delay
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group USER
    ./: main.c
  group CORE
    ../CORE/: system_at32f403a_407.c startup_at32f403a_407.s
    ../CORE/src/: at32f403a_407_clock.c at32f403a_407_int.c
  group AT32f403a_FWLIB
    ../AT32f403a_FWLIB/src/: at32f403a_407_acc.c at32f403a_407_adc.c at32f403a_407_bpr.c at32f403a_407_can.c at32f403a_407_crc.c at32f403a_407_crm.c at32f403a_407_dac.c at32f403a_407_debug.c at32f403a_407_dma.c at32f403a_407_emac.c at32f403a_407_exint.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_i2c.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_rtc.c at32f403a_407_sdio.c at32f403a_407_spi.c at32f403a_407_tmr.c at32f403a_407_usart.c at32f403a_407_usb.c at32f403a_407_wdt.c at32f403a_407_wwdt.c at32f403a_407_xmc.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/rvds/ARM_CM4F/: port.c
    ../FreeRTOS/portable/memmang/: heap_4.c
  group MY
    ../MY/: init.c dma_usart.c rs485_coder.c mellen.c kalman.c pid.c rm_motor.c vesc.c arm.c init_simplify.c key.c link_list.c my_library.c my_malloc.c walk_motor.c dm_motor.c input.c ak_motor.c free.c us.c hwt901.c ad7190.c nrf24l01.c sm.c chassis.c unitree.c oid.c state_machine.c message_center.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/delay/: delay.c
